# IAR project el_01.ewp, settings and files
configuration Debug (RL78, debug)
  General.GenCodeModel: 0
  General.GenDataModel: 0
  General.GenStackSize: 128
  General.GenNearHeapSize: 256
  General.GenFarHeapSize: 4096
  General.GenDeviceSelect: R5F102AA RL78 - R5F102AA
  ICCRL78.IccLang: 0
  ICCRL78.CCIncludePath2: user_src\
  XLINK.XlinkStackSize: 1
  XLINK.XclFile: applilet3_src\md_lnkr5f102aa.xcl
configuration Release (RL78)
  as the first configuration, except:
  ICCRL78.CCDefines: NDEBUG
  group applilet_src
    applilet3_src/: ADE7878_protocol.c r_cg_cgc.c r_cg_cgc_user.c r_cg_intc.c r_cg_intc_user.c r_cg_port.c r_cg_port_user.c r_cg_serial.c r_cg_serial_user.c r_cg_timer.c r_cg_timer_user.c r_cg_wdt.c r_cg_wdt_user.c r_main.c r_systeminit.c
