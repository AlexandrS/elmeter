# IAR project Backup of el_01.ewp, settings and files
configuration Debug (RL78, debug)
  General.GenDeviceSelect: R5F102AA RL78 - R5F102AA
  XLINK.XclFile: applilet3_src\md_lnkr5f102aa.xcl
configuration Release (RL78)
  as the first configuration, except:
  group applilet_src
    applilet3_src/: r_main.c r_systeminit.c r_cg_cgc.c r_cg_cgc_user.c r_cg_port.c r_cg_port_user.c r_cg_intc.c r_cg_intc_user.c r_cg_serial.c r_cg_serial_user.c r_cg_timer.c r_cg_timer_user.c r_cg_wdt.c r_cg_wdt_user.c
